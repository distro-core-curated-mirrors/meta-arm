FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://gcs.patch"
